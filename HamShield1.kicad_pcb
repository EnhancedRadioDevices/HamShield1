# Repository EnhancedRadioDevices/HamShield1

File README.md:

You can purchase HamShield (as well as smaller variants or LoRa version) at http://www.enhancedradio.com/

HamShield1.0b Hardware

These are the hardware design files for the HamShield1.0b electronics.

These hardware files were created with KiCAD.

You may need the KiCAD libraries available here: https://github.com/mogar/KiCAD_libs
When opening these projects in KiCAD, you may need to change the path to the libraries from the above link.
This can be done in preferences->libraries in both the schematic editor and the layout editor.
Make sure the libraries noted there point to wherever you put the above KiCAD_libs repo.

The Arduino Library for this project is available here: https://github.com/EnhancedRadioDevices/HamShield

## KiCad design HamShield1.kicad_pcb

Board: 4 copper layers, 53.3 x 68.6 mm, 161 parts (0 on the bottom side), 95 nets.

Parts:
C1, C3, C5, C7, C12, C14, C30: 1n; C_0402
C2, C4, C6, C8, C16, C17, C31, C35, C36, C37, C39, C43, C74, C75, C76: 0u1; C_0402
C9, C10, C15: 10p; C_0402
C11, C79, C93: 47u; C1210P
C13, C28, C29, C51: 1u; C_0402
C18, C21, C22, C78, C80: 10u; C_0805
C19, C23, C24, C25, C48, C67, C68, C70, C71, C73, C77: 100p; C_0603
C20: 4.7u; C_0603
C26, C38, C53, C62: 7p; C_0402
C27: 8p; C_0402
C32, C56, C63, C72: 14p; C_0402
C33, C61: 24p; C_0603
C34: 11p; C_0402
C40, C42, C47, C94: 2u2; C_0603
C41: 15n; C_0402
C44: 47p; C_0402
C45: 5.1p; C_0402
C46, C49: 2.2p; C_0402
C58, C66: 20p; C_0402
C59: 8.2p; C_0402
C60, C69: 15p; C_0402
C81: 22u; C_0805
C301: DNP; C_0603
D1: BAS40TW; SOT-363
D2, D3: LED; D_0603
FD1, FD2, FD3: FIDUCIAL1X2.5; SparkFun-FIDUCIAL-1X2.5
J1: SMA_EDGE; SMA-EDGE-HandSolder
J2: SJ-43514-SMT-TR
JP3: M04PTH; Pin_Header_Straight_1x04_Pitch2.54mm
L1, L10: 5.6n; C_0603
L2: NR5040T220M; NR5040
L3: 220n; C_0603
L4, L8: 3.9n; C_0402
L5: 3n; C_0603
L6: 3.6n; C_0402
L7, L16: 2n; C_0603
L9, L12: 6.2n; C_0603
L11: 0ohm; C_0402
L15: 100n; L_1008
L17: 3.3n; C_0402
L18, L27: 24n; C_0603
L19, L28: 47n; C_0603
L20, L29: 82n; C_0603
L21, L24: 33n; C_0603
L22, L25: 75n; C_0402
L23, L26: 120n; C_0805
L30, L31, L32, L33, L301: DNP; C_0603
P1: CONN_01X10; Pin_Header_Straight_1x10
Q1: NTGD1100L; SC-74
Q5, Q6, Q7: BSS138; SOT-23
R1, R4, R6, R7, R9, R11, R12, R13, R14, R15, R16, R36, R37: 10k; R_0402
R2, R3: 0; R_0402
R5: 49.9; R_0402
R8: 1.8; R_0402
R10: 52.3k; R_0402
R17: DNP; R_0402
R20, R22: 330; R_0402
R23: 13.3; R_0402
R24: 1.47k; R_0402
R27, R28: 100k; R_0402
R31: 2k; R_0402
S1: TAC_SWITCHSMD; SWITCH_TACTILE_SMD_8mmX5mm
U1: AU1846; QFN32-5x5
U2: MCP16311; DFN-8-1EP_3x2mm_Pitch0.5mm
U3: AD8591; SOT23-6
U4: TRF37A75; DFN-8-1EP_2x2mm_Pitch0.5mm
U5: ARDUINO_SHIELD; ARDUINO_UNO_SHIELD
U6: AP2125N-3.3TRG1; SOT-23
U9: TQP7M9105; SOT89-3_Housing
U10, U11: SKY13388; QFN-12-2mm-x-2mm
U12: NC7WZ14; SC-70-6
Y1: 12.8MHz; CRYSTAL-SMD-5X3

Connections:
+5V: C20.1, C29.2, C31.1, C35.1, C78.2, C79.1, C81.2, L2.2, Q1.4, R4.1, R10.1, U6.3, U10.3, U10.4, U11.3, U11.4
+5VL: R16.2, R36.2, R37.2, U5.5V
/AFOUT: C47.1, U1.9
/GPIO0: P1.2, U1.32
/GPIO1: P1.3, U1.31
/GPIO2: P1.4, U1.30
/GPIO3: P1.5, U1.29
/GPIO4: D1.2, P1.6, U1.28, U11.5, U12.1
/GPIO5: D1.1, P1.7, U1.27, U11.6, U12.3
/GPIO6: P1.8, U1.26
/GPIO7: P1.9, U1.25
/MIC_IN: C40.1, C94.1, U1.11
/MODE: R2.1, R17.1, U1.7
/PDN: R3.1, U1.24
/RF Front End/1.2m_IN: C24.1, U11.8
/RF Front End/1.2m_OUT: C68.1, U10.2
/RF Front End/2m_IN: C25.1, U11.2
/RF Front End/2m_OUT: C70.1, U10.8
/RF Front End/70cm_IN: C23.1, U11.9
/RF Front End/70cm_OUT: C67.1, U10.1
/RF Front End/ANT: C19.1, L32.2, U10.11
/RF Front End/RF_OUT: C71.2, C301.1, C301.2, L301.2, U1.18
/RF Front End/S2_IN: L11.2, U9.1
/RF Front End/STAGE1_OUT: C49.1, C73.1, L9.1, L33.2
/RF Front End/STAGE2_OUT: C48.2, U11.11
/RFin: C77.1, L31.1, U1.15
/SCLK: Q7.2, R15.1, U1.2
/SDIO: Q6.2, R14.1, U1.3
/User Interface/ARD_AUDIO_OUT: C42.2, R27.1, R28.1, U5.A2
/User Interface/PWM_AUDIO_IN: R24.2, U5.D3
/Y1: U10.5, U12.6
/Y2: U10.6, U12.4
/nRST: U2.3, U5.A3
/nSEN: Q5.2, R1.1, U1.8
AVDD: C18.1, C21.1, U2.4, U5.VIN
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, C18.2, C20.2, C21.2, C22.1, C26.2, C27.2, C28.2, C29.1, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C37.2, C38.2, C39.1, C41.1, C43.1, C44.2, C45.2, C46.2, C49.2, C51.2, C53.2, C56.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C66.2, C69.2, C72.2, C74.2, C75.2, C76.2, C78.1, C79.2, C80.1, C81.1, D1.3, D2.1, D3.1, J1.GND, J2.4, JP3.4, L30.2, L31.2, L32.1, L33.1, L301.1, P1.10, Q1.1, R5.1, R7.2, R9.2, R11.2, R17.2, R28.2, S1.3, S1.4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
unnamed: C9.1, U1.5, Y1.1
unnamed: C10.1, U1.6, Y1.3
unnamed: C11.1, U1.12
unnamed: C19.2, J1.SIG, R9.1
unnamed: C23.2, L18.2
unnamed: C24.2, L19.2
unnamed: C25.2, L20.2
unnamed: C26.1, L1.1, L9.2
unnamed: C27.1, L1.2, L4.1
unnamed: C28.1, U2.2
unnamed: C32.1, L4.2, L5.1
unnamed: C33.1, L5.2, L7.1
unnamed: C34.1, L6.1, L8.2
unnamed: C36.1, U2.7
unnamed: C36.2, L2.1, U2.6
unnamed: C38.1, L8.1, L10.2
unnamed: C40.2, C41.2, R24.1
unnamed: C42.1, C93.1, R13.2, R23.2
unnamed: C44.1, L7.2, L11.1
unnamed: C45.1, L10.1, L12.2
unnamed: C46.1, C48.1, L12.1
unnamed: C47.2, R6.1
unnamed: C53.1, L18.1, L21.2
unnamed: C56.1, L19.1, L22.2
unnamed: C58.1, L20.1, L23.2
unnamed: C59.1, L21.1, L24.2
unnamed: C60.1, L22.1, L25.2
unnamed: C61.1, L23.1, L26.2
unnamed: C62.1, L24.1, L27.2
unnamed: C63.1, L25.1, L28.2
unnamed: C66.1, L26.1, L29.2
unnamed: C67.2, L27.1
unnamed: C68.2, L28.1
unnamed: C69.1, L16.1, L17.2
unnamed: C70.2, L29.1
unnamed: C71.1, U4.2
unnamed: C72.1, L6.2, L17.1
unnamed: C73.2, L3.1, U4.7
unnamed: C75.1, L3.2, R8.1
unnamed: C77.2, L30.1, U10.9
unnamed: C93.2, J2.3, JP3.2
unnamed: C94.2, J2.1, JP3.1, R31.2
unnamed: D1.4, D1.5, D1.6, Q1.5
unnamed: D2.2, R20.2
unnamed: D3.2, R22.2
unnamed: J2.2, JP3.3
unnamed: L15.1, L16.2, U9.3
unnamed: Q1.6, R4.2
unnamed: Q5.3, R16.1, U5.A1
unnamed: Q6.3, R37.1, U5.A4
unnamed: Q7.3, R36.1, U5.A5
unnamed: R5.2, U11.1
unnamed: R10.2, R11.1, U2.1
unnamed: R7.1, R12.2, U3.3
unnamed: R6.2, R13.1, U3.4
unnamed: R23.1, U3.1
unnamed: S1.1, S1.2, U5.D2
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C12.1, C13.1, C14.1, C15.1, C17.2, C22.2, C39.2, C80.2, P1.1, Q5.1, Q6.1, Q7.1, R1.2, R2.2, R3.2, R12.1, R14.2, R15.2, R22.1, R27.2, U1.1, U1.4, U1.13, U1.16, U1.21, U1.23, U3.5, U3.6, U6.2, U12.5
VTX: C16.1, C30.1, C37.1, C43.2, C51.1, C74.1, C76.1, L15.2, Q1.2, Q1.3, R8.2, R20.1, R31.1, U4.1

File HamShield1b_files/HamShield1b_BoM_2017Dec13.xlsx:

Id | Designator | Package | Quantity | Designation | Mfg | Mfg PN | Distributor | Dist PN
1 | U11,U10 | QFN-12-2mm-x-2mm | 2 | SKY13388 | Skyworks | SKY13388 | DigiKey | 863-1647-1-ND
2 | J2 | SJ-43514-SMT-TR | 1 | SJ-43514-SMT-TR | CUI | SJ-43514-SMT-TR | DigiKey | CP-43514SJDKR-ND
3 | U1 | QFN32-5x5 | 1 | AU1846 | Auctus | AU1846 | Auctus | AU1846
4 | U3 | SOT23-6 | 1 | AD8591 | Analog Devices | AD8591ARTZ-REEL7 | DigiKey | AD8591ARTZ-REEL7DKR-ND
5 | S1 | SWITCH_TACTILE_SMD_8mmX5mm | 1 | TAC_SWITCHSMD | C&K | PTS645SM43SMTR92 LFS | DigiKey | CKN9112DKR-ND
6 | C44 | C_0402 | 1 | 47p | Murata | GJM1555C1H470JB01D | DigiKey | 490-14446-2-ND
7 | C46,C49 | C_0402 | 2 | 2.2p | Murata | GJM1555C1H2R2CB01D | DigiKey | 490-3091-2-ND
8 | L15 | C_1008 | 1 | 100n | Abracon | AISC-1008HQ-R10J-T | DigiKey | 535-12247-2-ND
9 | P1 | Pin_Header_Straight_1x10 | 1 | CONN_01X10 | DNP | DNP | DNP | DNP
10 | C20 | C_0603 | 1 | 4.7u | Yageo | CC0603KRX5R6BB475 | DigiKey | 311-1455-2-ND
11 | U9 | SOT89-3_Housing | 1 | TQP7M9105 | Qorvo | TQP7M9105 | Mouser | 772-TQP7M9105
12 | C1,C3,C5,C7,C12,C14,C30 | C_0402 | 7 | 1n | Yageo | CC0402KRX7R9BB102 | DigiKey | 311-1036-6-ND
13 | C2,C4,C6,C8,C16,C17,C31,C35,C36,C37,C39,C43,C75,C76,C74 | C_0402 | 15 | 0u1 | Taiyo-Yuden | LMK105BJ104KV-F | DigiKey | 587-1227-1-ND
14 | C9,C10,C15 | C_0402 | 3 | 10p | Murata | GJM1555C1H100JB01D | DigiKey | 490-3113-2-ND
15 | C13,C51,C28,C29 | C_0402 | 4 | 1u | Murata | GRM155R61A105KE15J | DigiKey | 490-6298-2-ND
16 | C19,C23,C24,C25,C48,C67,C73,C68,C70,C71,C77 | C_0603 | 11 | 100p | Johanson | 251R14S101JV4T | DigiKey | 712-1310-2-ND
17 | C40,C42,C47,C94 | C_0603 | 4 | 2u2 | Taiyo-Yuden | JMK107BJ225KAHT | DigiKey | 587-3386-6-ND
18 | C41 | C_0402 | 1 | 15n | Samsung | CL05F153ZA5NNNC | DigiKey | 1276-1742-2-ND
20 | C56,C63,C72,C32 | C_0402 | 4 | 14p | AVX | 04025U140GAT2A | Mouser | 581-04025U140GAT2A
21 | C59 | C_0402 | 1 | 8.2p | Murata | GJM1555C1H8R2CB01D | DigiKey | 490-3110-2-ND
22 | C60,C69 | C_0402 | 2 | 15p | Murata | GJM1555C1H150JB01D | DigiKey | 490-3117-2-ND
24 | R3,R2 | R_0402 | 2 | 0 | Vishay Dale | CRCW04020000Z0ED | DigiKey | 541-0.0JDKR-ND
25 | R12,R13,R36,R37,R4,R6,R7,R9,R11,R1,R14,R15,R16 | R_0402 | 13 | 10k | TE Connectivity | 1622826-4 | DigiKey | A106045TR-ND
27 | R23 | R_0402 | 1 | 13.3 | Vishay Dale | CRCW040213R3FKED | DigiKey | 541-13.3LDKR-ND
28 | R24 | R_0402 | 1 | 1.47k | Yageo | RC0402FR-071K47L | DigiKey | YAG3038TR-ND
29 | R27,R28 | R_0402 | 2 | 100k | Vishay Dale | CRCW0402100KJNED | DigiKey | 541-100KJDKR-ND
30 | R31 | R_0402 | 1 | 2k | Vishay Dale | CRCW04022K00JNED | DigiKey | 541-2.0KJDKR-ND
33 | Q1 | SC-74 | 1 | NTGD1100L | ON Semi | NTGD1100L | DigiKey | NTGD1100LT1GOSTR-ND
34 | R5 | R_0402 | 1 | 49.9 | Yageo | RC0402FR-0749R9L | DigiKey | 311-49.9LRTR-ND
35 | D1 | SOT-363 | 1 | BAS40TW | Diodes Inc. | BAS40TW | DigiKey | BAS40TW-FDITR-ND
36 | C58,C66 | C_0402 | 2 | 20p | Murata | GJM1555C1H200JB01D | DigiKey | 490-3120-2-ND
37 | U12 | SC-70-6 | 1 | NC7WZ14 | Fairchild Semi | NC7WZ14 | DigiKey | NC7WZ14P6XTR-ND
38 | C61,C33 | C_0603 | 2 | 24p | Murata | GQM1885C1H240GB01D | DigiKey | 490-8131-2-ND
39 | L18,L27 | C_0603 | 2 | 24n | Murata | LQW18AN24NJ00D | DigiKey | 490-6878-2-ND
40 | L19,L28 | C_0603 | 2 | 47n | Bourns | CW160808-47NJ | DigiKey | CW160808-47NJTR-ND
41 | L21,L24 | C_0603 | 2 | 33n | Murata | LQW18AN33NJ00D | DigiKey | 490-1175-2-ND
42 | C34 | C_0402 | 1 | 11p | Murata | GJM1555C1H110GB01D | DigiKey | 490-6072-2-ND
44 | C53,C62,C38,C26 | C_0402 | 4 | 7p | Murata | GJM1555C1H7R0CB01D | DigiKey | 490-3107-2-ND
45 | L1,L10 | C_0603 | 2 | 5.6n | Murata | LQW18AN5N6D00D | DigiKey | 490-1164-2-ND
46 | L5 | C_0603 | 1 | 3n | Murata | LQW18AN3N0C80D | DigiKey | 490-11771-2-ND
47 | L9,L12 | C_0603 | 2 | 6.2n | Murata | LQW18AN6N2D00D | DigiKey | 490-1163-2-ND
48 | L16,L7 | C_0603 | 2 | 2n | Johanson | L-14W2N0CV4E | DigiKey | 712-1618-2-ND
49 | L22,L25 | C_0402 | 2 | 75n | Murata | LQW15AN75NJ00D | DigiKey | 490-6843-1-ND
50 | L23,L26 | C_0805 | 2 | 120n | Bourns | PM0805-R12K-RC | DigiKey | M8464TR-ND
51 | R8 | R_0402 | 1 | 1.8 | Vishay Dale | CRCW04021R80JNED | DigiKey | 541-1.8JCT-ND
53 | C11,C79,C93 | C1210P | 3 | 47u | AVX | TAJB476K010RNJ | DigiKey | 478-1693-2-ND
54 | U4 | DFN-8-1EP_2x2mm_Pitch0.5mm | 1 | TRF37A75 | TI | TRF37A75 | DigiKey | 296-37886-1-ND
55 | L30,L31,L32,L33,C301,L301 | C_0603 | 6 | DNP
56 | R10 | R_0402 | 1 | 52.3k | Vishay Dale | CRCW040252K3FKED | DigiKey | 541-52.3KLCT-ND
57 | C18,C21,C78,C22,C80 | C_0805 | 5 | 10u | Murata | GRM21BR61E106KA73L | DigiKey | 490-5523-2-ND
58 | L2 | NR5040 | 1 | NR5040T220M | Taiyo-Yuden | NR5040T220M | DigiKey | 587-2368-2-ND
59 | L3 | C_0603 | 1 | 220n | TE Connectivity | 9-1624112-0 | DigiKey | A103722CT-ND
60 | L17 | C_0402 | 1 | 3.3n | Murata | LQW15AN3N3D10D | DigiKey | 490-6809-2-ND
61 | L20,L29 | C_0603 | 2 | 82n | Bourns | PM0603-82NJ-RC | DigiKey | M8491TR-ND
62 | C81 | C_0805 | 1 | 22u | Samsung | CL21A226MQQNNNE | DigiKey | 1276-1100-2-ND
63 | U2 | DFN-8-1EP_3x2mm_Pitch0.5mm | 1 | MCP16311 | Microchip | MCP16311T-E/MNY | Mouser | 579-MCP16311T-E/MNY
64 | J1 | SMA-EDGE-HandSolder | 1 | DNP | Linx | CONSMA003.062 | DigiKey | CONSMA003.062-ND
65 | R17 | R_0402 | 1 | DNP
66 | D2,D3 | D_0603 | 2 | LED | Lite-On | LTST-C190KGKT | DigiKey | 160-1435-2-ND
68 | R20,R22 | R_0402 | 2 | 330 | Yageo | RC0402JR-07330RL | DigiKey | 311-330JRTR-ND
69 | C27 | C_0402 | 1 | 8p | Murata | GJM1555C1H8R0CB01D | DigiKey | 490-3109-2-ND
70 | C45 | C_0402 | 1 | 5.1p | Murata | GJM1555C1H5R1CB01D | DigiKey | 490-3102-2-ND
71 | L4,L8 | C_0402 | 2 | 3.9n | Murata | LQW15AN3N9C00D | DigiKey | 490-6813-2-ND
72 | L6 | C_0402 | 1 | 3.6n | Abracon | AISC-0402-3N6G-T | DigiKey | AISC-0402-3N6G-TTR-ND
74 | L11 | C_0402 | 1 | 0ohm | Vishay Dale | CRCW04020000Z0ED | DigiKey | 541-0.0JDKR-ND
77 | JP3 | Pin_Header_Straight_1x04_Pitch2.54mm | 1 | DNP
78 | Q5,Q6,Q7 | SOT-23 | 3 | BSS138 | Fairchild Semi | BSS138 | DigiKey | BSS138TR-ND
79 | U6 | SOT-23 | 1 | AP2125N-3.3TRG1 | Diodes Inc. | AP2125N-3.3TRG1 | DigiKey | AP2125N-3.3TRG1DITR-ND
80 | Y1 | CRYSTAL-SMD-5X3 | 1 | 12.8MHz | CTS | 405C11A12M80000 | DigiKey | CTX957DKR-ND

## Commit log

2018-01-19 adding HS1 files
